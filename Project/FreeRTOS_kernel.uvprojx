# Keil uVision project FreeRTOS_kernel.uvprojx, settings and files
target FreeRTOS_kernel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOS_kernel
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\freertos\include;..\User;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Ports
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/Source
    ../freertos/include/: list.h FreeRTOS.h FreeRTOSConfig.h portmacro.h portable.h task.h projdefs.h
    ../freertos/: list.c task.c
  group doc
    ../Doc/: README.md
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
